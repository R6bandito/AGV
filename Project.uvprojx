# Keil uVision project Project.uvprojx, settings and files
target STM32F103ZET6 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Project +hex
  AfterMake: fromelf.exe --bin --output .\bin\ZET6bin\zet6FW.bin .\Objects\Project.axf
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xE
  c include: .\Core;.\Core\Device\STM32F103C8T6;.\Core\Device\STM32F103C8T6\C8T6 STARTUP;.\Core\Device\STM32F103ZET6;.\Core\Device\STM32F103ZET6\ZET6 STARTUP;.\Driver\BSP;.\Driver\HAL\Inc;.\Driver\HAL\Inc\Legacy;.\Driver\HAL;.\Usr\Inc;.\HardWare;.\Driver\FreeRTOS\inc;.\Driver\FreeRTOS\port;.\Driver\FreeRTOS;.\modbus;.\Driver\BSP
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  scatter file: .\sct\ZET6\ProjectZET6.sct
  group Core
    ./Core/: cmsis_armcc.h cmsis_compiler.h cmsis_version.h core_cm3.h
  group Core/Device/ZET6
    ./Core/Device/STM32F103ZET6/: stm32f1xx.h stm32f103xe.h system_stm32f1xx.c system_stm32f1xx.h
  group Core/Device/C8T6
    ./Core/Device/STM32F103C8T6/: stm32f1xx.h stm32f103xb.h system_stm32f1xx.c system_stm32f1xx.h
  group STARTUP_ZET6
    ./Core/Device/STM32F103ZET6/ZET6 STARTUP/: startup_stm32f103xe.s
  group STARTUP_C8T6
    ./Core/Device/STM32F103C8T6/C8T6 STARTUP/: startup_stm32f103xb.s
  group Driver/BSP
    ./Driver/BSP/: debug_uart.c debug_uart.h sys.c sys.h Cus_ILI9341.c Cus_ILI9341.h Cus_ILI9341_commands.h Cus_ILI9341_font.h Cus_ILI9341_port.c Cus_ILI9341_port.h Cus_ILI9341_port_stm32_fsmc.c Cus_ILI9341_port_stm32_fsmc.h
  group Driver/HAL/Inc
    ./Driver/HAL/Inc/: stm32f1xx_hal.h stm32f1xx_hal_adc.h stm32f1xx_hal_adc_ex.h stm32f1xx_hal_can.h stm32f1xx_hal_cec.h stm32f1xx_hal_cortex.h stm32f1xx_hal_crc.h stm32f1xx_hal_dac.h stm32f1xx_hal_dac_ex.h stm32f1xx_hal_def.h stm32f1xx_hal_dma.h stm32f1xx_hal_dma_ex.h stm32f1xx_hal_eth.h stm32f1xx_hal_exti.h stm32f1xx_hal_flash.h stm32f1xx_hal_flash_ex.h stm32f1xx_hal_gpio.h stm32f1xx_hal_gpio_ex.h stm32f1xx_hal_hcd.h stm32f1xx_hal_i2c.h stm32f1xx_hal_i2s.h stm32f1xx_hal_irda.h stm32f1xx_hal_iwdg.h stm32f1xx_hal_mmc.h stm32f1xx_hal_nand.h stm32f1xx_hal_nor.h stm32f1xx_hal_pccard.h stm32f1xx_hal_pcd.h stm32f1xx_hal_pcd_ex.h stm32f1xx_hal_pwr.h stm32f1xx_hal_rcc.h stm32f1xx_hal_rcc_ex.h stm32f1xx_hal_rtc.h stm32f1xx_hal_rtc_ex.h stm32f1xx_hal_sd.h stm32f1xx_hal_smartcard.h stm32f1xx_hal_spi.h stm32f1xx_hal_sram.h stm32f1xx_hal_tim.h stm32f1xx_hal_tim_ex.h stm32f1xx_hal_uart.h stm32f1xx_hal_usart.h stm32f1xx_hal_wwdg.h stm32f1xx_ll_adc.h stm32f1xx_ll_bus.h stm32f1xx_ll_cortex.h stm32f1xx_ll_crc.h stm32f1xx_ll_dac.h stm32f1xx_ll_dma.h stm32f1xx_ll_exti.h stm32f1xx_ll_fsmc.h stm32f1xx_ll_gpio.h stm32f1xx_ll_i2c.h stm32f1xx_ll_iwdg.h stm32f1xx_ll_pwr.h stm32f1xx_ll_rcc.h stm32f1xx_ll_rtc.h stm32f1xx_ll_sdmmc.h stm32f1xx_ll_spi.h stm32f1xx_ll_system.h stm32f1xx_ll_tim.h stm32f1xx_ll_usart.h stm32f1xx_ll_usb.h stm32f1xx_ll_utils.h stm32f1xx_ll_wwdg.h
    ./Driver/HAL/Inc/Legacy/: stm32_hal_legacy.h stm32f1xx_hal_can_ex_legacy.h stm32f1xx_hal_can_legacy.h
  group Driver/HAL_Src
    ./Driver/HAL/Src/: stm32f1xx_hal.c stm32f1xx_hal_adc.c stm32f1xx_hal_adc_ex.c stm32f1xx_hal_can.c stm32f1xx_hal_cec.c stm32f1xx_hal_cortex.c stm32f1xx_hal_crc.c stm32f1xx_hal_dac.c stm32f1xx_hal_dac_ex.c stm32f1xx_hal_dma.c stm32f1xx_hal_eth.c stm32f1xx_hal_exti.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_hcd.c stm32f1xx_hal_i2c.c stm32f1xx_hal_i2s.c stm32f1xx_hal_irda.c stm32f1xx_hal_iwdg.c stm32f1xx_hal_mmc.c stm32f1xx_hal_nand.c stm32f1xx_hal_nor.c stm32f1xx_hal_pccard.c stm32f1xx_hal_pcd.c stm32f1xx_hal_pcd_ex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_rtc.c stm32f1xx_hal_rtc_ex.c stm32f1xx_hal_sd.c stm32f1xx_hal_smartcard.c stm32f1xx_hal_spi.c stm32f1xx_hal_sram.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c stm32f1xx_hal_usart.c stm32f1xx_hal_wwdg.c stm32f1xx_ll_adc.c stm32f1xx_ll_crc.c stm32f1xx_ll_dac.c stm32f1xx_ll_dma.c stm32f1xx_ll_exti.c stm32f1xx_ll_fsmc.c stm32f1xx_ll_gpio.c stm32f1xx_ll_i2c.c stm32f1xx_ll_pwr.c stm32f1xx_ll_rcc.c stm32f1xx_ll_rtc.c stm32f1xx_ll_sdmmc.c stm32f1xx_ll_spi.c stm32f1xx_ll_tim.c stm32f1xx_ll_usart.c stm32f1xx_ll_usb.c stm32f1xx_ll_utils.c
  group Driver/HAL/Conf
    ./Driver/HAL/: stm32f1xx_hal_conf.h
  group HardWare
    ./HardWare/: CAN_Cus.c CAN_Cus.h Cus_CAN_IT.c Cus_CAN_IT.h Cus_CAN_RTOS.c Cus_CAN_RTOS.h motor_can_ctrl.c motor_can_ctrl.h
  group Usr/Inc
    ./Usr/Inc/: main.h stm32f1xx_it.h
  group Usr/Src
    ./Usr/Src/: main.c stm32f1xx_it.c
  group Driver/FreeRTOS/Src
    ./Driver/FreeRTOS/src/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group Driver/FreeRTOS/Inc
    ./Driver/FreeRTOS/inc/: atomic.h croutine.h deprecated_definitions.h event_groups.h FreeRTOS.h list.h message_buffer.h mpu_prototypes.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h stack_macros.h StackMacros.h stream_buffer.h task.h timers.h
  group Driver/FreeRTOS/Port
    ./Driver/FreeRTOS/port/: heap_4.c port.c portmacro.h
  group Driver/FreeRTOS/Conf
    ./Driver/FreeRTOS/: FreeRTOSConfig.h
  group modbus
    ./modbus/: mb.c mb.h mbascii.c mbascii.h mbconfig.h mbcrc.c mbcrc.h mbframe.h mbfunc.h mbfunccoils.c mbfuncdiag.c mbfuncdisc.c mbfuncfile.c mbfuncholding.c mbfuncinput.c mbfuncother.c mbport.h mbproto.h mbrtu.c mbrtu.h mbtcp.c mbtcp.h mbutils.c mbutils.h port.h portevent.c portserial.c porttimer.c mb_app.c mb_app.h
target STM32F103C8T6 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Project
  AfterMake: fromelf.exe --bin --output .\bin\C8T6bin\c8t6FW.bin .\Objects\Project.axf
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xB
  c include: .\Core;.\Core\Device\STM32F103C8T6;.\Core\Device\STM32F103C8T6\C8T6 STARTUP;.\Core\Device\STM32F103ZET6;.\Core\Device\STM32F103ZET6\ZET6 STARTUP;.\Driver\BSP;.\Driver\HAL\Inc;.\Driver\HAL\Inc\Legacy;.\Driver\HAL;.\Usr\Inc;.\HardWare
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  scatter file: .\sct\C8T6\ProjectC8T6.sct
